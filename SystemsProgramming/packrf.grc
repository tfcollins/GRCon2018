<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ConstantPacketTX</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label</key><value>Enable Constant Packet Generation</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>DebugSelect</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Debug Data Selector</value></param>
<param><key>labels</key><value>['Timing Locked','Peaks Found','Frequency Lock','Header Failures','CRC Errors','Packets Recovered','Last Payload Length']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>EQBypass</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:0,1,2,2</value></param>
<param><key>label</key><value>EQ Bypass</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>EQStepSize</value></param>
<param><key>value</key><value>0.0033</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>EQ Stepsize</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>0.9000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>FRLoopBandwidth</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Loop Bandwidth (Frequency Recovery PLL)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>128</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>LoopbackCtrl</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label0</key><value>"IP Loopback"</value></param>
<param><key>label1</key><value>"RF"</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>PDThreshold</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Packet Detect Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>PacketDecode</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@0:2,1,2,2</value></param>
<param><key>label</key><value>Packet Decode Enable</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>ScopeSelector</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label0</key><value>"After SRRC"</value></param>
<param><key>label1</key><value>"After Timing Recovery"</value></param>
<param><key>label2</key><value>"After Frequency Recovery"</value></param>
<param><key>label3</key><value>"After Equalization"</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>option2</key><value>3</value></param>
<param><key>option3</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>FreqRecLoopBandwidth</value></param>
<param><key>attr</key><value>str(int("0x100",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(FRLoopBandwidth)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>FreqRecLoopBandwidth_0</value></param>
<param><key>attr</key><value>str(int("0x104",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(int(1/EQStepSize))</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>FreqRecLoopBandwidth_0_0</value></param>
<param><key>attr</key><value>str(int("0x114",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(EQBypass)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>PDThreshold_au</value></param>
<param><key>attr</key><value>str(int("0x11C",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(PDThreshold)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>PDThreshold_au_0</value></param>
<param><key>attr</key><value>str(int("0x118",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(PacketDecode)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>PDThreshold_au_0_0</value></param>
<param><key>attr</key><value>str(int("0x124",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(ConstantPacketTX)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>PDThreshold_au_0_0_0</value></param>
<param><key>attr</key><value>str(int("0x10C",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(DebugSelect)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>iio_attr_sink</key>
<param><key>id</key><value>iio_attr_sink_0</value></param>
<param><key>attr_type</key><value>4</value></param>
<param><key>channel</key><value>""</value></param>
<param><key>device</key><value>"mwipcore0:mmwr0"</value></param>
<param><key>required_enable</key><value>True</value></param>
<param><key>uri</key><value>"ip:192.168.3.2"</value></param>
</block>
<block>
<key>iio_attr_source</key>
<param><key>id</key><value>iio_attr_source_0</value></param>
<param><key>attribute</key><value>""</value></param>
<param><key>attr_type</key><value>3</value></param>
<param><key>channel</key><value>""</value></param>
<param><key>type</key><value>1</value></param>
<param><key>device</key><value>"mwipcore0:mmrd0"</value></param>
<param><key>address</key><value>int("0x140",0)</value></param>
<param><key>required_enable</key><value>True</value></param>
<param><key>samples_per_update</key><value>128</value></param>
<param><key>update_interval_ms</key><value>1</value></param>
<param><key>uri</key><value>"ip:192.168.3.2"</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0</value></param>
<param><key>attr</key><value>str(int("0x108",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(ScopeSelector)</value></param>
</block>
<block>
<key>iio_fmcomms2_sink</key>
<param><key>id</key><value>iio_fmcomms2_sink_0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>uri</key><value>ip:192.168.3.2</value></param>
<param><key>frequency</key><value>2400000400</value></param>
<param><key>rf_port_select</key><value>"A"</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>samplerate</key><value>2084000</value></param>
<param><key>tx1_en</key><value>True</value></param>
<param><key>tx2_en</key><value>False</value></param>
</block>
<block>
<key>iio_fmcomms2_source</key>
<param><key>id</key><value>iio_fmcomms2_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>gain1</key><value>"slow_attack"</value></param>
<param><key>uri</key><value>ip:192.168.3.2</value></param>
<param><key>frequency</key><value>2400000000</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>False</value></param>
<param><key>samplerate</key><value>2084000</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>loopback_ctrl</value></param>
<param><key>attr</key><value>str(int("0x12C",0))</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(LoopbackCtrl)</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>4</value></param>
<param><key>xmin</key><value>-4</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>3000</value></param>
<param><key>min</key><value>-3000</value></param>
<param><key>name</key><value>"Debug Register Output"</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Receiver</value></param>
<param><key>label1</key><value>Transmitter</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>FreqRecLoopBandwidth</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>FreqRecLoopBandwidth_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>FreqRecLoopBandwidth_0_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>PDThreshold_au</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>PDThreshold_au_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>PDThreshold_au_0_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>PDThreshold_au_0_0_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>iio_fmcomms2_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_attr_source_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>loopback_ctrl</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
</flow_graph>
